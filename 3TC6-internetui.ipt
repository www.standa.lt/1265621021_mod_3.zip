# Autodesk Inventor part: 3TC6-internetui
## iProperties
Created: 2010-02
Part Number: 3TC6-internetui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
